# Keil uVision project 12.uvprojx, settings and files
target 12 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: 12 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;        F:/software/STM32CubeMX561/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Inc;        F:/software/STM32CubeMX561/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;        F:/software/STM32CubeMX561/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/CMSIS/Device/ST/STM32G4xx/Include;        F:/software/STM32CubeMX561/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: lcd_hal.c lcd.c led.c key.c main.c gpio.c dma.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
    ../Inc/: lcd.h led.h key.h
  group Drivers/STM32G4xx_HAL_Driver
    F:/software/STM32CubeMX561/Repository/STM32Cube_FW_G4_V1.2.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_gpio.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
